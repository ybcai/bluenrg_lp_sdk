# IAR project DTM_Updater.ewp, settings and files
configuration UART (ARM)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_LS_RO; UART_INTERFACE; NO_DMA; UART_BAUDRATE=921600
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\..\Middlewares\ST\NVMDB\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DTM_Updater.bin
  postbuild: "convert_bin2c.exe" -i "UART\Exe\DTM_Updater.bin" -o "DTM_Updater_UART.c"
  ILINK.IlinkOutputFile: DTM_Updater.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=8192
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SPI (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_LS_RO; SPI_INTERFACE; __DMA_16
  postbuild: "convert_bin2c.exe" -i "SPI\Exe\DTM_Updater.bin" -o "DTM_Updater_SPI.c"
  group User
    ../../src/: DTM_Updater.c DTM_Updater_boot.c DTM_Updater_main.c
