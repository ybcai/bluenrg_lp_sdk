# Keil uVision project BLE_SensorDemo_StaticStack.uvprojx, settings and files
target Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BLE_SensorDemo_StaticStack +hex
  AfterMake: fromelf.exe --bin Release\Objects\BLE_SensorDemo_StaticStack.axf --output Release\Objects\BLE_SensorDemo_StaticStack.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_HW_LS_XTAL BLE_STACK_FULL_CONF CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: ..\..\..\BLE_SensorDemo\Inc;..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\Drivers\CMSIS\Include;../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\..\..\..\..\Drivers\BSP\Common\Inc;..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=0x22800 -DMEMORY_RAM_APP_OFFSET=0x0810 "
  group Drivers/BSP
    ../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_i2c.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c bluenrg_lp_evb_mic.c bluenrg_lp_evb_spi.c
    ../../../../../Drivers/BSP/Components/lps22hh_STdC/driver/: lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver/: lsm6dsox_reg.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal_power_manager.c bluenrg_lp_ll_adc.c bluenrg_lp_ll_crc.c bluenrg_lp_ll_dma.c bluenrg_lp_ll_exti.c bluenrg_lp_ll_flash.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_i2c.c bluenrg_lp_ll_lpuart.c bluenrg_lp_ll_pka.c bluenrg_lp_ll_pwr.c bluenrg_lp_ll_rcc.c bluenrg_lp_ll_rng.c bluenrg_lp_ll_rtc.c bluenrg_lp_ll_spi.c bluenrg_lp_ll_tim.c bluenrg_lp_ll_timer.c bluenrg_lp_ll_usart.c bluenrg_lp_ll_utils.c
  group Example/User
    ../../../BLE_SensorDemo/Src/: bluenrg_lp_it.c gatt_db.c sensor.c SensorDemo_main.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/static_stack/: bluenrg_lp_stack_init_if.c libbluenrg_lp_static_stack.a libbluenrg_lp_static_stack_with_resetmanager.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s clock.c context_switch.s gp_timer.c hal_miscutil.c miscutil.c osal.c
  group Middlewares/OTA
    ../../../../../Middlewares/ST/BLE_Application/OTA/Src/: OTA_btl.c
target LowerApp_OTA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: BLE_SensorDemo_StaticStack_LowerApp_OTA +hex
  AfterMake: fromelf.exe --bin LowerApp_OTA\Objects\BLE_SensorDemo_StaticStack_LowerApp_OTA.axf --output LowerApp_OTA\Objects\BLE_SensorDemo_StaticStack_LowerApp_OTA.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_HW_LS_XTAL BLE_STACK_FULL_CONF CONFIG_SW_OTA_DATA_LENGTH_EXT CONFIG_OTA_LOWER RESET_MANAGER_SIZE=0x22800 CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  link misc: --predefine="-DCONFIG_OTA_LOWER=1 -DRESET_MANAGER_SIZE=0x22800 -DMEMORY_RAM_APP_OFFSET=0x0810 "
target HigherApp_OTA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: BLE_SensorDemo_StaticStack_HigherApp_OTA +hex
  AfterMake: fromelf.exe --bin HigherApp_OTA\Objects\BLE_SensorDemo_StaticStack_HigherApp_OTA.axf --output HigherApp_OTA\Objects\BLE_SensorDemo_StaticStack_HigherApp_OTA.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 USER_BUTTON=BSP_PUSH1 CONFIG_HW_LS_XTAL BLE_STACK_FULL_CONF CONFIG_SW_OTA_DATA_LENGTH_EXT CONFIG_OTA_HIGHER RESET_MANAGER_SIZE=0x22800 CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  link misc: --predefine="-DCONFIG_OTA_HIGHER=1 -DRESET_MANAGER_SIZE=0x22800 -DMEMORY_RAM_APP_OFFSET=0x0810 "
software components: CMSIS:CORE 5.1.1
