# Keil uVision project DTM_basic.uvprojx, settings and files
target UART (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: DTM_basic_UART +hex
  AfterMake: fromelf.exe --bin UART\Objects\DTM_basic_UART.axf --output UART\Objects\DTM_basic_UART.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER UART_INTERFACE UART_BAUDRATE=921600 WATCHDOG WATCHDOG_TIME=1 BLE_STACK_BASIC_CONF NUM_ADV_SETS_CONF=2 CONFIG_NUM_MAX_LINKS=8 CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: ..\..\..\DTM\Inc;..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\Drivers\BSP\STEVAL-IDB010V1\Inc;../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\..\..\..\..\Drivers\BSP\Common\Inc;..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Queued_Write\Inc;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Queued_Write\Inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Application/DTM_Updater
    ../../../DTM/DTM_Updater/: DTM_Updater_SPI.c DTM_Updater_UART.c
  group Application/User
    ../../../DTM/Src/: aci_adv_nwk.c aci_gatt_nwk.c aci_l2cap_nwk.c adv_buff_alloc_tiny.c bluenrg_lp_it.c cmd.c dm_alloc.c DTM_boot.c DTM_burst.c DTM_cmd_db.c DTM_cmds.c DTM_main.c hci_parser.c hw_config.c transport_layer.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal_power_manager.c bluenrg_lp_hal_vtimer.c bluenrg_lp_ll_dma.c bluenrg_lp_ll_exti.c bluenrg_lp_ll_flash.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_pka.c bluenrg_lp_ll_rcc.c bluenrg_lp_ll_spi.c bluenrg_lp_ll_timer.c bluenrg_lp_ll_usart.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_dle_api_stubs.c stack_ext_adv_api_stubs.c stack_l2cap_cos_api_stubs.c stack_phy_upd_stubs.c stack_priv_api_stubs.c stack_sc_api_stubs.c stack_slvonly_api_stubs.c stack_user_cfg.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s context_switch.s fifo.c hal_miscutil.c miscutil.c osal.c
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/Queued_Write
    ../../../../../Middlewares/ST/BLE_Application/Queued_Write/Src/: att_pwrq.c
target UART_WITH_UPDATER (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: DTM_basic_UART_WITH_UPDATER +hex
  AfterMake: fromelf.exe --bin UART_WITH_UPDATER\Objects\DTM_basic_UART_WITH_UPDATER.axf --output UART_WITH_UPDATER\Objects\DTM_basic_UART_WITH_UPDATER.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=8192 "
target UART_FOR_UPDATER (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: DTM_basic_UART_FOR_UPDATER +hex
  AfterMake: fromelf.exe --bin UART_FOR_UPDATER\Objects\DTM_basic_UART_FOR_UPDATER.axf --output UART_FOR_UPDATER\Objects\DTM_basic_UART_FOR_UPDATER.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=8192 "
target SPI (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: DTM_basic_SPI +hex
  AfterMake: fromelf.exe --bin SPI\Objects\DTM_basic_SPI.axf --output SPI\Objects\DTM_basic_SPI.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER SPI_INTERFACE WATCHDOG WATCHDOG_TIME=1 BLE_STACK_BASIC_CONF __DMA_16 NUM_ADV_SETS_CONF=2 CONFIG_NUM_MAX_LINKS=8 CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
target SPI_WITH_UPDATER (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: DTM_basic_SPI_WITH_UPDATER +hex
  AfterMake: fromelf.exe --bin SPI_WITH_UPDATER\Objects\DTM_basic_SPI_WITH_UPDATER.axf --output SPI_WITH_UPDATER\Objects\DTM_basic_SPI_WITH_UPDATER.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: ..\..\..\DTM\Inc;..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include;..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver;..\..\..\..\..\Drivers\BSP\STEVAL-IDB010V1\Inc;../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\..\..\..\..\Drivers\BSP\Common\Inc;..\..\..\..\..\Middlewares\ST\hal\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc;..\..\..\..\..\Middlewares\ST\BLE_Application\Queued_Write\Inc;..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc;..\..\..\..\..\Middlewares\ST\NVMDB\Inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=8192 "
target SPI_FOR_UPDATER (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: DTM_basic_SPI_FOR_UPDATER +hex
  AfterMake: fromelf.exe --bin SPI_FOR_UPDATER\Objects\DTM_basic_SPI_FOR_UPDATER.axf --output SPI_FOR_UPDATER\Objects\DTM_basic_SPI_FOR_UPDATER.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  link misc: --predefine="-DMEMORY_FLASH_APP_OFFSET=8192 "
software components: CMSIS:CORE 5.1.1
