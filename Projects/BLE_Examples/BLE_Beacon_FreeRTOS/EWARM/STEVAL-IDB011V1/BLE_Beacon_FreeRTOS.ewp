# IAR project BLE_Beacon_FreeRTOS.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; USER_BUTTON=BSP_PUSH1; CONFIG_HW_LS_XTAL; BLE_STACK_BASIC_CONF; SAVE_CONTEXT_ON_CSTACK=0
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers/BSP/STEVAL-IDB011V1/Inc; ..\..\..\..\..\Drivers\BSP\Common\Inc; ..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\..\Middlewares\ST\NVMDB\Inc; ..\..\..\..\..\Middlewares\ST\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\ST\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\..\..\..\..\Middlewares\ST\FreeRTOS\BlueNRG; ..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\inc
  OBJCOPY.OOCOutputFile: BLE_Beacon_FreeRTOS.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\BLE_Beacon_FreeRTOS.bin"
  ILINK.IlinkOutputFile: BLE_Beacon_FreeRTOS.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkExtraOptions: --use_optimized_variants no
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP
    ../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_i2c.c bluenrg_lp_evb_io.c bluenrg_lp_evb_led.c bluenrg_lp_evb_mic.c bluenrg_lp_evb_spi.c
    ../../../../../Drivers/BSP/Components/lps22hh_STdC/driver/: lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver/: lsm6dsox_reg.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal_power_manager.c bluenrg_lp_hal_vtimer.c bluenrg_lp_ll_adc.c bluenrg_lp_ll_crc.c bluenrg_lp_ll_dma.c bluenrg_lp_ll_exti.c bluenrg_lp_ll_flash.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_i2c.c bluenrg_lp_ll_lpuart.c bluenrg_lp_ll_pka.c bluenrg_lp_ll_pwr.c bluenrg_lp_ll_radio.c bluenrg_lp_ll_rcc.c bluenrg_lp_ll_rng.c bluenrg_lp_ll_rtc.c bluenrg_lp_ll_spi.c bluenrg_lp_ll_tim.c bluenrg_lp_ll_timer.c bluenrg_lp_ll_usart.c bluenrg_lp_ll_utils.c
  group Example/User
    ../../Src/: BLE_Beacon_FreeRTOS_main.c bluenrg_lp_it.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_user_cfg.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: libcrypto.a
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/ST/FreeRTOS/BlueNRG/: freertos_lp.c
    ../../../../../Middlewares/ST/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/ST/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../../../Middlewares/ST/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s context_switch.s fifo.c hal_miscutil.c miscutil.c osal.c
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/OTA
    ../../../../../Middlewares/ST/BLE_Application/OTA/Src/: OTA_btl.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
