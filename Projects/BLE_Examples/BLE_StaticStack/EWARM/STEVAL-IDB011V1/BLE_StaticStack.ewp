# IAR project BLE_StaticStack.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; CONFIG_DEVICE_BLUENRG_LP; RESET_MANAGER_SIZE=0x22800; BLE_STACK_FULL_CONF
  ICCARM.CCDiagSuppress: Pe1665
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers/BSP/STEVAL-IDB011V1/Inc; ..\..\..\..\..\Drivers\BSP\Common\Inc; ..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\OTA\inc; ..\..\..\..\..\Middlewares\ST\NVMDB\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static_stack
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_StaticStack.hex
  postbuild: "..\..\..\..\..\Utility\create_sym_lib.exe" --symbols "..\..\sym_export.txt" --rename BLE_STACK_Init=BLE_STACK_Init_nocallbacks "$TARGET_PATH$" "..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static_stack\libbluenrg_lp_static_stack.a"
  ILINK.IlinkOutputFile: BLE_StaticStack.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_SIZE=0x22800
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkExtraOptions: --use_optimized_variants no
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration OTA_BTL_ResetManager (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: BLE_StaticStack_OTA_BTL_ResetManager.hex
  postbuild: "..\..\..\..\..\Utility\create_sym_lib.exe" --symbols "..\..\sym_export.txt" --rename BLE_STACK_Init=BLE_STACK_Init_nocallbacks "$TARGET_PATH$" "..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Library\static_stack\libbluenrg_lp_static_stack_with_resetmanager.a"
  ILINK.IlinkOutputFile: BLE_StaticStack_OTA_BTL_ResetManager.out
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal_vtimer.c bluenrg_lp_ll_flash.c bluenrg_lp_ll_pka.c bluenrg_lp_ll_timer.c
  group Example/User
    ../../src/: bluenrg_lp_cmd_if.c bluenrg_lp_ev_if.c bluenrg_lp_it.c Reset_Manager.c
    ../../../BLE_OTA_ResetManager/Src/: OTA_ResetManager_main.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_user_cfg.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s hal_miscutil.c miscutil.c osal.c
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
