# IAR project DTM.ewp, settings and files
configuration UART (ARM)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CONFIG_DEVICE_BLUENRG_LP; USE_FULL_LL_DRIVER; UART_INTERFACE; UART_BAUDRATE=921600; WATCHDOG; WATCHDOG_TIME=1; NUM_ADV_SETS_CONF=2; BLE_STACK_FULL_CONF; CONFIG_NUM_MAX_LINKS=8
  ICCARM.CCDiagSuppress: Pe1665, Pa183
  ICCARM.CCIncludePath2: $; ..\..\Inc; ..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\Drivers\BSP\STEVAL-IDB010V1\Inc; ..\..\..\..\..\Drivers\BSP\STEVAL-IDB011V1\Inc; ..\..\..\..\..\Drivers\BSP\Common\Inc; ..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\..\Middlewares\ST\NVMDB\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\Queued_Write\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DTM_UART.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_UART.bin"
  ILINK.IlinkOutputFile: DTM_UART.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkExtraOptions: --use_optimized_variants no
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration UART_WITH_UPDATER (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_DEVICE_BLUENRG_LP; USE_FULL_LL_DRIVER; UART_INTERFACE; UART_BAUDRATE=921600; WATCHDOG; WATCHDOG_TIME=1; BLE_STACK_FULL_CONF; NUM_ADV_SETS_CONF=2; CONFIG_NUM_MAX_LINKS=8
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include; ..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\Drivers\BSP\STEVAL-IDB010V1\Inc; ..\..\..\..\..\Drivers\BSP\STEVAL-IDB011V1\Inc; ..\..\..\..\..\Drivers\BSP\Common\Inc; ..\..\..\..\..\Middlewares\ST\hal\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\layers_inc; ..\..\..\..\..\Middlewares\ST\Bluetooth_LE\Inc; ..\..\..\..\..\Middlewares\ST\NVMDB\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\Profiles\Inc; ..\..\..\..\..\Middlewares\ST\BLE_Application\Queued_Write\Inc
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: DTM_UART_WITH_UPDATER.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_UART_WITH_UPDATER.bin"
  ILINK.IlinkOutputFile: DTM_UART_WITH_UPDATER.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=8192
configuration UART_FOR_UPDATER (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: DTM_UART_FOR_UPDATER.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_UART_FOR_UPDATER.bin"
  ILINK.IlinkOutputFile: DTM_UART_FOR_UPDATER.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=8192
configuration SPI (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CONFIG_DEVICE_BLUENRG_LP; USE_FULL_LL_DRIVER; SPI_INTERFACE; WATCHDOG; WATCHDOG_TIME=2; BLE_STACK_FULL_CONF; __DMA_16; NUM_ADV_SETS_CONF=2; CONFIG_NUM_MAX_LINKS=8
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: DTM_SPI.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_SPI.bin"
  ILINK.IlinkOutputFile: DTM_SPI.out
configuration SPI_WITH_UPDATER (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: DTM_SPI_WITH_UPDATER.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_SPI_WITH_UPDATER.bin"
  ILINK.IlinkOutputFile: DTM_SPI_WITH_UPDATER.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=8192
configuration SPI_FOR_UPDATER (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: DTM_SPI_FOR_UPDATER.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\DTM_SPI_FOR_UPDATER.bin"
  ILINK.IlinkOutputFile: DTM_SPI_FOR_UPDATER.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=8192
  group Application/DTM_Updater
    ../../DTM_Updater/: DTM_Updater_SPI.c DTM_Updater_UART.c
  group Application/User
    ../../Src/: aci_adv_nwk.c aci_gatt_nwk.c aci_l2cap_nwk.c adv_buff_alloc.c bluenrg_lp_it.c cmd.c dm_alloc.c DTM_boot.c DTM_burst.c DTM_cmd_db.c DTM_cmds.c DTM_main.c hci_parser.c hw_config.c transport_layer.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal_power_manager.c bluenrg_lp_hal_vtimer.c bluenrg_lp_ll_dma.c bluenrg_lp_ll_exti.c bluenrg_lp_ll_flash.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_pka.c bluenrg_lp_ll_rcc.c bluenrg_lp_ll_spi.c bluenrg_lp_ll_timer.c bluenrg_lp_ll_usart.c
  group Middlewares/BLE_Stack
    ../../../../../Middlewares/ST/Bluetooth_LE/Library/: libbluenrg_lp_stack.a
    ../../../../../Middlewares/ST/Bluetooth_LE/Src/: stack_dle_api_stubs.c stack_ext_adv_api_stubs.c stack_l2cap_cos_api_stubs.c stack_phy_upd_stubs.c stack_priv_api_stubs.c stack_sc_api_stubs.c stack_slvonly_api_stubs.c stack_user_cfg.c
  group Middlewares/Cryptolib
    ../../../../../Middlewares/ST/cryptolib/: libcrypto.a
  group Middlewares/Hal
    ../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s context_switch.s fifo.c hal_miscutil.c miscutil.c osal.c
  group Middlewares/NVM
    ../../../../../Middlewares/ST/NVMDB/Src/: nvm_db.c nvm_db_conf.c nvm_db_upper_layer.c
  group Middlewares/Profiles
    ../../../../../Middlewares/ST/BLE_Application/Profiles/Src/: gap_profile.c gatt_profile.c
  group Middlewares/Queued_Write
    ../../../../../Middlewares/ST/BLE_Application/Queued_Write/Src/: att_pwrq.c
