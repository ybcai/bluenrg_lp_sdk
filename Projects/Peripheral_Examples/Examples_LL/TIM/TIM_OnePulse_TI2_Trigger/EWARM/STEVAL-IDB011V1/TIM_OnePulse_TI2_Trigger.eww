<workspace>
  <project>
    <path>$WS_DIR$\TIM_OnePulse_TI2_Trigger.ewp</path>
  </project>
  <batchBuild />
</workspace>