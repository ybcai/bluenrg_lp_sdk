<workspace>
  <project>
    <path>$WS_DIR$\TIM_BreakAndDeadtime_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>