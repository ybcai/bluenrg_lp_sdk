<workspace>
  <project>
    <path>$WS_DIR$\TIM_InputCapture_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>