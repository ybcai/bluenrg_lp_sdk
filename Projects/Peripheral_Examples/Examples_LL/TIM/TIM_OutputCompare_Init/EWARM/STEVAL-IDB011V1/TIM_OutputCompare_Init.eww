<workspace>
  <project>
    <path>$WS_DIR$\TIM_OutputCompare_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>