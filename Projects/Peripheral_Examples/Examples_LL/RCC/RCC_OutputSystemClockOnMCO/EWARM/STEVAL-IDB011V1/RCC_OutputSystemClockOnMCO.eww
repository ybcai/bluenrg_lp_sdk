<workspace>
  <project>
    <path>$WS_DIR$\RCC_OutputSystemClockOnMCO.ewp</path>
  </project>
  <batchBuild />
</workspace>