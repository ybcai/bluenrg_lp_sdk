<workspace>
  <project>
    <path>$WS_DIR$\IWDG_RefreshUntilUserEvent_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>