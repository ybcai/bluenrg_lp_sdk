<workspace>
  <project>
    <path>$WS_DIR$\PDM_DigitalMicrophone.ewp</path>
  </project>
  <batchBuild />
</workspace>