<workspace>
  <project>
    <path>$WS_DIR$\RNG_GenerateRandomNumbers.ewp</path>
  </project>
  <batchBuild />
</workspace>