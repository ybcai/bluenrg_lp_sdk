<workspace>
  <project>
    <path>$WS_DIR$\DMA_CopyFromMemoryToMemory.ewp</path>
  </project>
  <batchBuild />
</workspace>