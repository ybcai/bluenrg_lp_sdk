<workspace>
  <project>
    <path>$WS_DIR$\SPI_OneBoard_HalfDuplex_DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>