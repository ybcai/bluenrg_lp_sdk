<workspace>
  <project>
    <path>$WS_DIR$\SPI_FullDuplex_DMA_Master_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>