<workspace>
  <project>
    <path>$WS_DIR$\SPI_FullDuplex_DMA_Slave_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>