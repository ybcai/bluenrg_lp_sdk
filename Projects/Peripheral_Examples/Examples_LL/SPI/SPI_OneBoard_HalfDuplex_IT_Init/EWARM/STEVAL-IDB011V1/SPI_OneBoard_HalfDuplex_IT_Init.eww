<workspace>
  <project>
    <path>$WS_DIR$\SPI_OneBoard_HalfDuplex_IT_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>