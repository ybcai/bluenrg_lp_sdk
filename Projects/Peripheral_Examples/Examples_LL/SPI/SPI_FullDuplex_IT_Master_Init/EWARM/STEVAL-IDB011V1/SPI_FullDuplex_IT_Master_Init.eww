<workspace>
  <project>
    <path>$WS_DIR$\SPI_FullDuplex_IT_Master_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>