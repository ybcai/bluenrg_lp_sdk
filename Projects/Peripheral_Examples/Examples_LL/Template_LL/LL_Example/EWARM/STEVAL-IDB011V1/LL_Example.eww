<workspace>
  <project>
    <path>$WS_DIR$\LL_Example.ewp</path>
  </project>
  <batchBuild />
</workspace>