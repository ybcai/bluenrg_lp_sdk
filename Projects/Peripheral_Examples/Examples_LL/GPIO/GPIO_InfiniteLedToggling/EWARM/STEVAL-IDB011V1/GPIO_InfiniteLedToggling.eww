<workspace>
  <project>
    <path>$WS_DIR$\GPIO_InfiniteLedToggling.ewp</path>
  </project>
  <batchBuild />
</workspace>