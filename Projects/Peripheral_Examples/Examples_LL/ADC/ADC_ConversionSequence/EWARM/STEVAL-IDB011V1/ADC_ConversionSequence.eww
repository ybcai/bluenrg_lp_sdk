<workspace>
  <project>
    <path>$WS_DIR$\ADC_ConversionSequence.ewp</path>
  </project>
  <batchBuild />
</workspace>