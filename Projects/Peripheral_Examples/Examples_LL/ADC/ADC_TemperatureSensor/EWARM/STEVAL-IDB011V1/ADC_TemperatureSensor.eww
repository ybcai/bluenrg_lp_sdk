<workspace>
  <project>
    <path>$WS_DIR$\ADC_TemperatureSensor.ewp</path>
  </project>
  <batchBuild />
</workspace>