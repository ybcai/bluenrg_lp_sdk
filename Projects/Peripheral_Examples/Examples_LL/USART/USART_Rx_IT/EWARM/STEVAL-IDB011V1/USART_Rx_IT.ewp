# IAR project USART_Rx_IT.ewp, settings and files
configuration USART_Rx_IT (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BLUENRG_LP\Include; ..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\../../../../../../Middlewares/ST/hal/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USART_Rx_IT.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\USART_Rx_IT.bin"
  ILINK.IlinkOutputFile: USART_Rx_IT.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BLUENRG_LP_LL_Driver
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_ll_utils.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_usart.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Example/User
    ../../Src/: bluenrg_lp_it.c USART_Rx_IT_main.c
