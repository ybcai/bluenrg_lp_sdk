# Keil uVision project USART_Rx_IT.uvprojx, settings and files
target USART_Rx_IT (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: USART_Rx_IT +hex
  AfterMake: fromelf.exe --bin USART_Rx_IT\Objects\USART_Rx_IT.axf --output USART_Rx_IT\Objects\USART_Rx_IT.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BLUENRG_LP\Include;..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\../../../../../../Middlewares/ST/hal/inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Drivers/BLUENRG_LP_LL_Driver
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_ll_utils.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_usart.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Example/User
    ../../Src/: bluenrg_lp_it.c USART_Rx_IT_main.c
software components: CMSIS:CORE 5.1.1
