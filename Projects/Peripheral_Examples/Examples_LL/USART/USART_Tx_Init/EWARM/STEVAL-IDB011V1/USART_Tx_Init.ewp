# IAR project USART_Tx_Init.ewp, settings and files
configuration USART_Tx_Init (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\../Inc; ..\../../../../../../Drivers/Peripherals_Drivers/Inc; ..\../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Include; ..\../../../../../../Middlewares/ST/hal/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USART_Tx_Init.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\USART_Tx_Init.bin"
  ILINK.IlinkOutputFile: USART_Tx_Init.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../Src/: bluenrg_lp_it.c USART_Tx_Init_main.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_ll_dma.c bluenrg_lp_ll_exti.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_pwr.c bluenrg_lp_ll_rcc.c bluenrg_lp_ll_usart.c bluenrg_lp_ll_utils.c
