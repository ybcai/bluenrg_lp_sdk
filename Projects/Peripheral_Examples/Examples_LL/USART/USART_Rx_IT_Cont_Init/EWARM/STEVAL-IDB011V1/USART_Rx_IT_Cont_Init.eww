<workspace>
  <project>
    <path>$WS_DIR$\USART_Rx_IT_Cont_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>