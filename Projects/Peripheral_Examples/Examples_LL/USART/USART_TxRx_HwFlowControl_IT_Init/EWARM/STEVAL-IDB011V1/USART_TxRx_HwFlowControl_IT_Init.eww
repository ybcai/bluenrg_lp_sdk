<workspace>
  <project>
    <path>$WS_DIR$\USART_TxRx_HwFlowControl_IT_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>