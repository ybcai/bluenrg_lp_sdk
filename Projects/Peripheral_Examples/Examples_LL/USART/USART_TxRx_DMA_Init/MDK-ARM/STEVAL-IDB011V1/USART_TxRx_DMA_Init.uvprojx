# Keil uVision project USART_TxRx_DMA_Init.uvprojx, settings and files
target USART_TxRx_DMA_Init (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: USART_TxRx_DMA_Init +hex
  AfterMake: fromelf.exe --bin USART_TxRx_DMA_Init\Objects\USART_TxRx_DMA_Init.axf --output USART_TxRx_DMA_Init\Objects\USART_TxRx_DMA_Init.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL USE_FULL_LL_DRIVER CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BLUENRG_LP\Include;..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\../../../../../../Middlewares/ST/hal/inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Drivers/BLUENRG_LP_LL_Driver
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_ll_utils.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Example/User
    ../../Src/: bluenrg_lp_it.c USART_TxRx_DMA_Init_main.c
  group Example
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_ll_exti.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_usart.c
software components: CMSIS:CORE 5.1.1
