# IAR project I2C_TwoBoards_MasterRx_SlaveTx_IT_Init.ewp, settings and files
configuration I2C_TwoBoards_MasterRx_SlaveTx_IT_Init (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STEVAL_IDB011V1; USE_FULL_LL_DRIVER; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BLUENRG_LP\Include; ..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\../../../../../../Middlewares/ST/hal/inc; ..\../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc; ..\../../../../../../Drivers/BSP/Common/Inc; ..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver; ..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_TwoBoards_MasterRx_SlaveTx_IT_Init.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\I2C_TwoBoards_MasterRx_SlaveTx_IT_Init.bin"
  ILINK.IlinkOutputFile: I2C_TwoBoards_MasterRx_SlaveTx_IT_Init.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Master_board (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: I2C_TwoBoards_MasterRx_SlaveTx_IT_Init_Master.hex
configuration Slave_board (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_IDB011V1; USE_FULL_LL_DRIVER; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL; SLAVE_BOARD
  OBJCOPY.OOCOutputFile: I2C_TwoBoards_MasterRx_SlaveTx_IT_Init_Slave.hex
  group Drivers/BLUENRG_LP_LL_Driver
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_ll_utils.c
  group Drivers/BSP/BLUENRG_LP_EVB
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Example
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_ll_exti.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_i2c.c
  group Example/User
    ../../Src/: bluenrg_lp_it.c I2C_TwoBoards_MasterRx_SlaveTx_IT_Init_main.c
