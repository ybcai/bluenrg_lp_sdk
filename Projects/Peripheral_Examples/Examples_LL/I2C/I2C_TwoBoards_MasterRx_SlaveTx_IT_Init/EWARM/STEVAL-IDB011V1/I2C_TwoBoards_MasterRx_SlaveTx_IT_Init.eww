<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\I2C_TwoBoards_MasterRx_SlaveTx_IT_Init.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BATCH_BUILD</name>
            <member>
                <project>I2C_TwoBoards_MasterRx_SlaveTx_IT_Init</project>
                <configuration>I2C_TwoBoards_MasterRx_SlaveTx_IT_Init</configuration>
            </member>
            <member>
                <project>I2C_TwoBoards_MasterRx_SlaveTx_IT_Init</project>
                <configuration>Master_board</configuration>
            </member>
            <member>
                <project>I2C_TwoBoards_MasterRx_SlaveTx_IT_Init</project>
                <configuration>Slave_board</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
