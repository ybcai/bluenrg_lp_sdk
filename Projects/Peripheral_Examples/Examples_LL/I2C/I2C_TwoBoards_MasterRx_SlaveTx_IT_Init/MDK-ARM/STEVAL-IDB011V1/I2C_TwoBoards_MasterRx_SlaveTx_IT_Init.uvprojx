# Keil uVision project I2C_TwoBoards_MasterRx_SlaveTx_IT_Init.uvprojx, settings and files
target I2C_TwoBoards_MasterRx_SlaveTx_IT_Init (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: I2C_TwoBoards_MasterRx_SlaveTx_IT_Init +hex
  AfterMake: fromelf.exe --bin I2C_TwoBoards_MasterRx_SlaveTx_IT_Init\Objects\I2C_TwoBoards_MasterRx_SlaveTx_IT_Init.axf --output I2C_TwoBoards_MasterRx_SlaveTx_IT_Init\Objects\I2C_TwoBoards_MasterRx_SlaveTx_IT_Init.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BLUENRG_LP\Include;..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\../../../../../../Middlewares/ST/hal/inc;../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\../../../../../../Drivers/BSP/Common/Inc;..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver;..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Drivers/BLUENRG_LP_LL_Driver
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_ll_utils.c
  group Drivers/BLUENRG_LP_EVB/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Example/User
    ../../Src/: bluenrg_lp_it.c I2C_TwoBoards_MasterRx_SlaveTx_IT_Init_main.c
  group Example
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_ll_exti.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_i2c.c
target Master_board (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: I2C_TwoBoards_MasterRx_SlaveTx_IT_Init_Master_board +hex
  AfterMake: fromelf.exe --bin Master_board\Objects\I2C_TwoBoards_MasterRx_SlaveTx_IT_Init_Master_board.axf --output Master_board\Objects\I2C_TwoBoards_MasterRx_SlaveTx_IT_Init_Master_board.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
target Slave_board (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: I2C_TwoBoards_MasterRx_SlaveTx_IT_Init_Slave_board +hex
  AfterMake: fromelf.exe --bin Slave_board\Objects\I2C_TwoBoards_MasterRx_SlaveTx_IT_Init_Slave_board.axf --output Slave_board\Objects\I2C_TwoBoards_MasterRx_SlaveTx_IT_Init_Slave_board.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_FULL_LL_DRIVER CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL SLAVE_BOARD CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
software components: CMSIS:CORE 5.1.1
