<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\I2C_TwoBoards_MasterTx_SlaveRx_Init.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BUILD_ALL</name>
            <member>
                <project>I2C_TwoBoards_MasterTx_SlaveRx_Init</project>
                <configuration>I2C_TwoBoards_MasterTx_SlaveRx_Init</configuration>
            </member>
            <member>
                <project>I2C_TwoBoards_MasterTx_SlaveRx_Init</project>
                <configuration>Master_board</configuration>
            </member>
            <member>
                <project>I2C_TwoBoards_MasterTx_SlaveRx_Init</project>
                <configuration>Slave_board</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
