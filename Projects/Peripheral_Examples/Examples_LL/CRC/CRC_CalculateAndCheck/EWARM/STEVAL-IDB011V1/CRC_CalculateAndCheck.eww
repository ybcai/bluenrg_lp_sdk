<workspace>
  <project>
    <path>$WS_DIR$\CRC_CalculateAndCheck.ewp</path>
  </project>
  <batchBuild />
</workspace>