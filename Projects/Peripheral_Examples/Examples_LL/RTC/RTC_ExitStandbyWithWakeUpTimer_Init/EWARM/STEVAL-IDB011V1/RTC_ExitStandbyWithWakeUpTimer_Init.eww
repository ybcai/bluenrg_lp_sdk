<workspace>
  <project>
    <path>$WS_DIR$\RTC_ExitStandbyWithWakeUpTimer_Init.ewp</path>
  </project>
  <batchBuild />
</workspace>