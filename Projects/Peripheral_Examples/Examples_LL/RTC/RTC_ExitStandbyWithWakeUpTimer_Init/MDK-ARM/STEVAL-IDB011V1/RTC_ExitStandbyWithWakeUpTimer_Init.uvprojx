# Keil uVision project RTC_ExitStandbyWithWakeUpTimer_Init.uvprojx, settings and files
target Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RTC_ExitStandbyWithWakeUpTimer_Init +hex
  AfterMake: fromelf.exe --bin Release\Objects\RTC_ExitStandbyWithWakeUpTimer_Init.axf --output Release\Objects\RTC_ExitStandbyWithWakeUpTimer_Init.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL USE_FULL_LL_DRIVER CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: ..\..\Inc;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BLUENRG_LP\Include;..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc;..\../../../../../../Middlewares/ST/hal/inc;..\../../../../../../Middlewares/ST/Bluetooth_LE/Inc;../../../../.././../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\..\..\..\..\.\..\..\Drivers\BSP\Common\Inc;..\..\..\..\..\.\..\..\Drivers\BSP\Components\lps22hh_STdC\driver;..\..\..\..\..\.\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Drivers/BLUENRG_LP_LL_Driver
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal_power_manager.c bluenrg_lp_ll_adc.c bluenrg_lp_ll_crc.c bluenrg_lp_ll_dma.c bluenrg_lp_ll_exti.c bluenrg_lp_ll_flash.c bluenrg_lp_ll_gpio.c bluenrg_lp_ll_i2c.c bluenrg_lp_ll_lpuart.c bluenrg_lp_ll_pka.c bluenrg_lp_ll_pwr.c bluenrg_lp_ll_rcc.c bluenrg_lp_ll_rng.c bluenrg_lp_ll_rtc.c bluenrg_lp_ll_spi.c bluenrg_lp_ll_tim.c bluenrg_lp_ll_usart.c bluenrg_lp_ll_utils.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Example/User
    ../../Src/: bluenrg_lp_it.c RTC_ExitStandbyWithWakeUpTimer_Init_main.c
  group Middlewares/Hal
    ../../../../../../../Middlewares/ST/hal/Src/: context_switch.s hal_miscutil.c
software components: CMSIS:CORE 5.1.1
