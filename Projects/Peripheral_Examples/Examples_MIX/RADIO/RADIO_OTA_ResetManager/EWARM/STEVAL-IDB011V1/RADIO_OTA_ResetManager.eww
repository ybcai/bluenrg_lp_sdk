<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\RADIO_OTA_ResetManager.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>build all</name>
            <member>
                <project>RADIO_OTA_ResetManager</project>
                <configuration>Client</configuration>
            </member>
            <member>
                <project>RADIO_OTA_ResetManager</project>
                <configuration>Server_FixedImage</configuration>
            </member>
            <member>
                <project>RADIO_OTA_ResetManager</project>
                <configuration>Server_Ymodem</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
