# IAR project RADIO_TxRx.ewp, settings and files
configuration Tx (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Middlewares\ST\hal\inc; ..\..\..\..\..\..\..\Drivers\BSP\Common\Inc; ..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\..\..\Drivers/BSP/STEVAL-IDB011V1/Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RADIO_TxRx_Tx.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_TxRx_Tx.bin"
  ILINK.IlinkOutputFile: RADIO_TxRx_Tx.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Rx (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\; ..\..\Inc; ..\..\..\..\..\..\..\Middlewares\ST\hal\inc; ..\..\..\..\..\..\..\Drivers\BSP\Common\Inc; ..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hh_STdC\driver; ..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsox_STdC\driver; ..\..\..\..\..\..\..\Drivers\Peripherals_Drivers\Inc; ..\..\..\..\..\..\..\Drivers/BSP/STEVAL-IDB011V1/Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\BlueNRG_LP\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: RADIO_TxRx_Rx.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_TxRx_Rx.bin"
  ILINK.IlinkOutputFile: RADIO_TxRx_Rx.out
configuration Tx_2M (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL; TXRX_PHY_2M
  OBJCOPY.OOCOutputFile: RADIO_TxRx_Tx_2M.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_TxRx_Tx_2M.bin"
  ILINK.IlinkOutputFile: RADIO_TxRx_Tx_2M.out
configuration Rx_2M (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL; TXRX_PHY_2M
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: RADIO_TxRx_Rx_2M.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_TxRx_Rx_2M.bin"
  ILINK.IlinkOutputFile: RADIO_TxRx_Rx_2M.out
configuration Tx_Use_OTA_ResetManager (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STEVAL_IDB011V1; ST_USE_OTA_RESET_MANAGER; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  OBJCOPY.OOCOutputFile: RADIO_TxRx_Tx_Use_OTA_ResetManager.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_TxRx_Tx_Use_OTA_ResetManager.bin"
  ILINK.IlinkOutputFile: RADIO_TxRx_Tx_Use_OTA_ResetManager.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=0x2800
configuration Rx_Use_OTA_ResetManager (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: RADIO_TxRx_Rx_Use_OTA_ResetManager.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RADIO_TxRx_Rx_Use_OTA_ResetManager.bin"
  ILINK.IlinkOutputFile: RADIO_TxRx_Rx_Use_OTA_ResetManager.out
  ILINK.IlinkConfigDefines: MEMORY_FLASH_APP_OFFSET=0x2800
  group Application/User
    ../../Src/: bluenrg_lp_it.c RADIO_TxRx_RX_main.c RADIO_TxRx_TX_main.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripheral_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal_radio.c bluenrg_lp_hal_vtimer.c bluenrg_lp_ll_radio.c bluenrg_lp_ll_timer.c
  group Hal
    ../../../../../../../Middlewares/ST/hal/Src/: blue_unit_conversion.s osal.c radio_ota.c
