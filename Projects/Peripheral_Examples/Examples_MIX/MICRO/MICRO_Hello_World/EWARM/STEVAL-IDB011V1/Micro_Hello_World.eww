<workspace>
  <project>
    <path>$WS_DIR$\Micro_Hello_World.ewp</path>
  </project>
  <batchBuild />
</workspace>