<workspace>
  <project>
    <path>$WS_DIR$\Micro_PowerManager.ewp</path>
  </project>
  <batchBuild />
</workspace>