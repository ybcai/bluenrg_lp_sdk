<workspace>
  <project>
    <path>$WS_DIR$\Example_MIX.ewp</path>
  </project>
  <batchBuild />
</workspace>