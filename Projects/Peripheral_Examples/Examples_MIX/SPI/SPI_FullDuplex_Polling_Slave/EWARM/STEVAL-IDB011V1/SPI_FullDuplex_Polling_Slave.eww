<workspace>
  <project>
    <path>$WS_DIR$\SPI_FullDuplex_Polling_Slave.ewp</path>
  </project>
  <batchBuild />
</workspace>