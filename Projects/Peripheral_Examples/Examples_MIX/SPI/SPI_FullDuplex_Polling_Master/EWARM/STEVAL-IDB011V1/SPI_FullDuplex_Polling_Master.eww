<workspace>
  <project>
    <path>$WS_DIR$\SPI_FullDuplex_Polling_Master.ewp</path>
  </project>
  <batchBuild />
</workspace>