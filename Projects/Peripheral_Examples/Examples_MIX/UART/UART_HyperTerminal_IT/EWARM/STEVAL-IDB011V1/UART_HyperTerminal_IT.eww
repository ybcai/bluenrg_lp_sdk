<workspace>
  <project>
    <path>$WS_DIR$\UART_HyperTerminal_IT.ewp</path>
  </project>
  <batchBuild />
</workspace>