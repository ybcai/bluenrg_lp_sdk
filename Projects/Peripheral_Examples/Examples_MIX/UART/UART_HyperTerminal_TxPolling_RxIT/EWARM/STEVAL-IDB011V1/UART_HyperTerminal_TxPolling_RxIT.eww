<workspace>
  <project>
    <path>$WS_DIR$\UART_HyperTerminal_TxPolling_RxIT.ewp</path>
  </project>
  <batchBuild />
</workspace>