# IAR project HAL_TimeBase_RTC_ALARM.ewp, settings and files
configuration HAL_TimeBase_RTC_ALARM (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\../Inc; ..\../../../../../../Drivers/Peripherals_Drivers/Inc; ..\../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Include; ..\../../../../../../Drivers/BSP/Common/Inc; ..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver; ..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver; ..\../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc; ..\../../../../../../Middlewares/ST/hal/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HAL_TimeBase_RTC_ALARM.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\HAL_TimeBase_RTC_ALARM.bin"
  ILINK.IlinkOutputFile: HAL_TimeBase_RTC_ALARM.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../Src/: bluenrg_lp_hal_timebase_rtc_alarm.c HAL_TimeBase_RTC_ALARM_main.c bluenrg_lp_it.c bluenrg_lp_hal_msp.c
  group Drivers/BSP/BLUENRG_LP_EVB
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_led.c bluenrg_lp_evb_com.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal_rtc.c bluenrg_lp_hal_rtc_ex.c bluenrg_lp_hal_gpio.c bluenrg_lp_hal_rcc.c bluenrg_lp_hal_rcc_ex.c bluenrg_lp_hal_flash.c bluenrg_lp_hal_flash_ex.c bluenrg_lp_hal_dma.c bluenrg_lp_hal_pwr.c bluenrg_lp_hal_pwr_ex.c bluenrg_lp_hal_cortex.c bluenrg_lp_hal.c
    ./:  
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
