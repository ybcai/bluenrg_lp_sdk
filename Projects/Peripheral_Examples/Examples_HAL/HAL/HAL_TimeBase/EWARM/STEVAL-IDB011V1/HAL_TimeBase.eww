<workspace>
  <project>
    <path>$WS_DIR$\HAL_TimeBase.ewp</path>
  </project>
  <batchBuild />
</workspace>