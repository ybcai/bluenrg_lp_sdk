<workspace>
  <project>
    <path>$WS_DIR$\HAL_TimeBase_RTC_WKUP.ewp</path>
  </project>
  <batchBuild />
</workspace>