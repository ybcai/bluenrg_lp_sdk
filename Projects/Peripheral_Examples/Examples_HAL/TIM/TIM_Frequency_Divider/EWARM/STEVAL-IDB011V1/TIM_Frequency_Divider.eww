<workspace>
  <project>
    <path>$WS_DIR$\TIM_Frequency_Divider.ewp</path>
  </project>
  <batchBuild />
</workspace>