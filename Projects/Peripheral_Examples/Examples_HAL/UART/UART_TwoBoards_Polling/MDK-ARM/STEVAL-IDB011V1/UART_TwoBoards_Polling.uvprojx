# Keil uVision project UART_TwoBoards_Polling.uvprojx, settings and files
target UART_TwoBoards_Polling (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: UART_TwoBoards_Polling +hex
  AfterMake: fromelf.exe --bin UART_TwoBoards_Polling\Objects\UART_TwoBoards_Polling.axf --output UART_TwoBoards_Polling\Objects\UART_TwoBoards_Polling.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: ..\../Inc;..\../../../../../../Drivers/Peripherals_Drivers/Inc;..\../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Include;..\../../../../../../Drivers/BSP/Common/Inc;..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver;..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver;../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\../../../../../../Middlewares/ST/hal/inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Application/User
    ../../Src/: bluenrg_lp_hal_msp.c bluenrg_lp_it.c UART_TwoBoards_Polling_main.c
  group Drivers/BLUENRG_LP_EVB/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal.c bluenrg_lp_hal_cortex.c bluenrg_lp_hal_dma.c bluenrg_lp_hal_flash.c bluenrg_lp_hal_flash_ex.c bluenrg_lp_hal_gpio.c bluenrg_lp_hal_pwr.c bluenrg_lp_hal_pwr_ex.c bluenrg_lp_hal_rcc.c bluenrg_lp_hal_rcc_ex.c bluenrg_lp_hal_uart.c bluenrg_lp_hal_uart_ex.c
target Transmitter_board (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: UART_TwoBoards_Polling_Transmitter_board +hex
  AfterMake: fromelf.exe --bin Transmitter_board\Objects\UART_TwoBoards_Polling_Transmitter_board.axf --output Transmitter_board\Objects\UART_TwoBoards_Polling_Transmitter_board.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL TRANSMITTER_BOARD CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
target Receiver_board (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: as above
  output: UART_TwoBoards_Polling_Receiver_board +hex
  AfterMake: fromelf.exe --bin Receiver_board\Objects\UART_TwoBoards_Polling_Receiver_board.axf --output Receiver_board\Objects\UART_TwoBoards_Polling_Receiver_board.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: as above
  c include: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
software components: CMSIS:CORE 5.1.1
