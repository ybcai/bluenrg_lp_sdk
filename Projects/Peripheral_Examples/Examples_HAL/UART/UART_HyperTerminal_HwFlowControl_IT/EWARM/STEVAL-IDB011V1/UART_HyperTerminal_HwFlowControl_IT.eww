<workspace>
  <project>
    <path>$WS_DIR$\UART_HyperTerminal_HwFlowControl_IT.ewp</path>
  </project>
  <batchBuild />
</workspace>