<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\UART_TwoBoards_IT.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>BUILD_ALL</name>
            <member>
                <project>UART_TwoBoards_IT</project>
                <configuration>Receiver_board</configuration>
            </member>
            <member>
                <project>UART_TwoBoards_IT</project>
                <configuration>Transmitter_board</configuration>
            </member>
            <member>
                <project>UART_TwoBoards_IT</project>
                <configuration>UART_TwoBoards_IT</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
