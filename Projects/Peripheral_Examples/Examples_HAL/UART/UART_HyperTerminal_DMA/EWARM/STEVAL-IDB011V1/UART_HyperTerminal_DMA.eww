<workspace>
  <project>
    <path>$WS_DIR$\UART_HyperTerminal_DMA.ewp</path>
  </project>
  <batchBuild />
</workspace>