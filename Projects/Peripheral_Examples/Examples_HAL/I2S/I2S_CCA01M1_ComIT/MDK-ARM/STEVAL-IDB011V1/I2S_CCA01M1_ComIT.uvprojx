# Keil uVision project I2S_CCA01M1_ComIT.uvprojx, settings and files
target I2S_CCA01M1_ComIT (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: I2S_CCA01M1_ComIT +hex
  AfterMake: fromelf.exe --bin I2S_CCA01M1_ComIT\Objects\I2S_CCA01M1_ComIT.axf --output I2S_CCA01M1_ComIT\Objects\I2S_CCA01M1_ComIT.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: ..\../Inc;..\../../../../../../Drivers/Peripherals_Drivers/Inc;..\../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Include;..\../../../../../../Drivers/BSP/Common/Inc;..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver;..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver;../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\../../../../../../Middlewares/ST/hal/inc
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Application/User
    ../../Src/: audio_application.c bluenrg_lp_hal_msp.c bluenrg_lp_it.c cca01m1_audio.c I2S_CCA01M1_ComIT_main.c sta350bw.c sta350bw_reg.c
  group Doc
    ../../: readme.txt
  group Drivers/BLUENRG_LP_EVB/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_com.c bluenrg_lp_evb_led.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal.c bluenrg_lp_hal_cortex.c bluenrg_lp_hal_dma.c bluenrg_lp_hal_exti.c bluenrg_lp_hal_flash.c bluenrg_lp_hal_flash_ex.c bluenrg_lp_hal_gpio.c bluenrg_lp_hal_i2c.c bluenrg_lp_hal_i2c_ex.c bluenrg_lp_hal_i2s.c bluenrg_lp_hal_pwr.c bluenrg_lp_hal_pwr_ex.c bluenrg_lp_hal_rcc.c bluenrg_lp_hal_rcc_ex.c
software components: CMSIS:CORE 5.1.1
