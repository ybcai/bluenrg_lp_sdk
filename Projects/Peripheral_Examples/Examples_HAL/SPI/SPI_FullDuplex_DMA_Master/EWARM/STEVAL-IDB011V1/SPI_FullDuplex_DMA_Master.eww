<workspace>
  <project>
    <path>$WS_DIR$\SPI_FullDuplex_DMA_Master.ewp</path>
  </project>
  <batchBuild />
</workspace>