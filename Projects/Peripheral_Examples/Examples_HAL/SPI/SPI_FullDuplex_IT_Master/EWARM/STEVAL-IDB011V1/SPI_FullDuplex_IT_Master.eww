<workspace>
  <project>
    <path>$WS_DIR$\SPI_FullDuplex_IT_Master.ewp</path>
  </project>
  <batchBuild />
</workspace>