<workspace>
  <project>
    <path>$WS_DIR$\SPI_FullDuplex_DMA_Slave.ewp</path>
  </project>
  <batchBuild />
</workspace>