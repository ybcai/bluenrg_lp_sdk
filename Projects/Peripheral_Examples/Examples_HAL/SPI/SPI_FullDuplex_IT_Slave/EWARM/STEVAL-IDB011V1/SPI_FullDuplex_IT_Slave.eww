<workspace>
  <project>
    <path>$WS_DIR$\SPI_FullDuplex_IT_Slave.ewp</path>
  </project>
  <batchBuild />
</workspace>