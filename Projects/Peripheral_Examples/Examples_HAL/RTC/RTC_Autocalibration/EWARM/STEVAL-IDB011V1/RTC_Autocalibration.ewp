# IAR project RTC_Autocalibration.ewp, settings and files
configuration RTC_Autocalibration (ARM, debug)
  General.OGChipSelectEditMenu: BlueNRG-355 ST BlueNRG-355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STEVAL_IDB011V1; CONFIG_DEVICE_BLUENRG_LP; CONFIG_HW_SMPS_10uH; CONFIG_HW_HSE_TUNE=32; CONFIG_HW_LS_XTAL
  ICCARM.CCIncludePath2: ..\../Inc; ..\../../../../../../Drivers/Peripherals_Drivers/Inc; ..\../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Include; ..\../../../../../../Drivers/BSP/Common/Inc; ..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver; ..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver; ..\../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc; ..\../../../../../../Middlewares/ST/hal/inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RTC_Autocalibration.hex
  postbuild: ielftool.exe --bin --verbose "$TARGET_PATH$" "$TARGET_DIR$\RTC_Autocalibration.bin"
  ILINK.IlinkOutputFile: RTC_Autocalibration.out
  ILINK.IlinkIcfFile: BlueNRG_LP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../Src/: bluenrg_lp_hal_msp.c bluenrg_lp_it.c RTC_Autocalibration_main.c
  group Drivers/BSP/BLUENRG_LP_EVB
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_led.c bluenrg_lp_evb_com.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal.c bluenrg_lp_hal_cortex.c bluenrg_lp_hal_crc.c bluenrg_lp_hal_crc_ex.c bluenrg_lp_hal_dma.c bluenrg_lp_hal_exti.c bluenrg_lp_hal_flash.c bluenrg_lp_hal_flash_ex.c bluenrg_lp_hal_gpio.c bluenrg_lp_hal_i2c.c bluenrg_lp_hal_i2c_ex.c bluenrg_lp_hal_irda.c bluenrg_lp_hal_iwdg.c bluenrg_lp_hal_pka.c bluenrg_lp_hal_pwr.c bluenrg_lp_hal_pwr_ex.c bluenrg_lp_hal_rcc.c bluenrg_lp_hal_rcc_ex.c bluenrg_lp_hal_rng.c bluenrg_lp_hal_rtc.c bluenrg_lp_hal_rtc_ex.c bluenrg_lp_hal_smartcard.c bluenrg_lp_hal_smartcard_ex.c bluenrg_lp_hal_smbus.c bluenrg_lp_hal_spi.c bluenrg_lp_hal_spi_ex.c bluenrg_lp_hal_tim.c bluenrg_lp_hal_tim_ex.c bluenrg_lp_hal_uart.c bluenrg_lp_hal_uart_ex.c bluenrg_lp_hal_usart.c bluenrg_lp_hal_usart_ex.c
