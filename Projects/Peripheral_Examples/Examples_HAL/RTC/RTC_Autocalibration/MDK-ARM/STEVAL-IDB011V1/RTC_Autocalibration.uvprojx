# Keil uVision project RTC_Autocalibration.uvprojx, settings and files
target RTC_Autocalibration (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: BlueNRG-355 STMicroelectronics
  pack: Keil.STBlueNRG-LP_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x10040000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RTC_Autocalibration +hex
  AfterMake: fromelf.exe --bin RTC_Autocalibration\Objects\RTC_Autocalibration.axf --output RTC_Autocalibration\Objects\RTC_Autocalibration.bin
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER CONFIG_HW_SMPS_10uH CONFIG_HW_HSE_TUNE=32 CONFIG_HW_LS_XTAL CONFIG_DEVICE_BLUENRG_LP STEVAL_IDB011V1
  c include: ..\../Inc;..\../../../../../../Drivers/Peripherals_Drivers/Inc;..\../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Include;..\../../../../../../Drivers/BSP/Common/Inc;..\../../../../../../Drivers/BSP/Components/lsm6dsox_STdC/driver;..\../../../../../../Drivers/BSP/Components/lps22hh_STdC/driver;../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Inc;..\../../../../../../Middlewares/ST/hal/inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: BlueNRG_LP.sct
  group Application/User
    ../../Src/: bluenrg_lp_hal_msp.c bluenrg_lp_it.c RTC_Autocalibration_main.c
  group Drivers/BLUENRG_LP_EVB/BSP
    ../../../../../../../Drivers/BSP/STEVAL-IDB011V1/Src/: bluenrg_lp_evb_button.c bluenrg_lp_evb_led.c bluenrg_lp_evb_com.c
  group Drivers/CMSIS
    ../../../../../../../Drivers/CMSIS/Device/ST/BlueNRG_LP/Source/: system_BlueNRG_LP.c
  group Drivers/Peripherals_Drivers
    ../../../../../../../Drivers/Peripherals_Drivers/Src/: bluenrg_lp_hal.c bluenrg_lp_hal_cortex.c bluenrg_lp_hal_crc.c bluenrg_lp_hal_crc_ex.c bluenrg_lp_hal_dma.c bluenrg_lp_hal_exti.c bluenrg_lp_hal_flash.c bluenrg_lp_hal_flash_ex.c bluenrg_lp_hal_gpio.c bluenrg_lp_hal_i2c.c bluenrg_lp_hal_i2c_ex.c bluenrg_lp_hal_irda.c bluenrg_lp_hal_iwdg.c bluenrg_lp_hal_pka.c bluenrg_lp_hal_pwr.c bluenrg_lp_hal_pwr_ex.c bluenrg_lp_hal_rcc.c bluenrg_lp_hal_rcc_ex.c bluenrg_lp_hal_rng.c bluenrg_lp_hal_rtc.c bluenrg_lp_hal_rtc_ex.c bluenrg_lp_hal_smartcard.c bluenrg_lp_hal_smartcard_ex.c bluenrg_lp_hal_smbus.c bluenrg_lp_hal_spi.c bluenrg_lp_hal_spi_ex.c bluenrg_lp_hal_tim.c bluenrg_lp_hal_tim_ex.c bluenrg_lp_hal_uart.c bluenrg_lp_hal_uart_ex.c bluenrg_lp_hal_usart.c bluenrg_lp_hal_usart_ex.c
software components: CMSIS:CORE 5.1.1
