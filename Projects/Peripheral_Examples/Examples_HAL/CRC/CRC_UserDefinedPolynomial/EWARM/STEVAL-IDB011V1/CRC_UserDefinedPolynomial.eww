<workspace>
  <project>
    <path>$WS_DIR$\CRC_UserDefinedPolynomial.ewp</path>
  </project>
  <batchBuild />
</workspace>