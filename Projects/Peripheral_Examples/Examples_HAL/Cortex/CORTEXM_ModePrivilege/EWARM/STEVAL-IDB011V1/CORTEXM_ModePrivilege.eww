<workspace>
  <project>
    <path>$WS_DIR$\CORTEXM_ModePrivilege.ewp</path>
  </project>
  <batchBuild />
</workspace>