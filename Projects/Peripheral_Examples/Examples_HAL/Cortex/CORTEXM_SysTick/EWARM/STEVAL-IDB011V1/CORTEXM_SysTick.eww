<workspace>
  <project>
    <path>$WS_DIR$\CORTEXM_SysTick.ewp</path>
  </project>
  <batchBuild />
</workspace>