<workspace>
  <project>
    <path>$WS_DIR$\FLASH_WriteProtection.ewp</path>
  </project>
  <batchBuild />
</workspace>